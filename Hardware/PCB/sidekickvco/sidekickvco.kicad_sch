File: Hardware/PCB/sidekickvco/sidekickvco.kicad_sch (KiCad schematic)
At the start: 17 parts, among them J1 Conn_01x06, J10 Conn_01x03, J11 Conn_01x04, J12 3_pin_Molex_connector, J13 Wire pads, J14 Conn_01x01, J15 Conn_01x01, J16 Conn_01x01, J17 Conn_02x04_Odd_Even, J2 Conn_01x03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

Commit message: Initial version of circuit and layout
Parts:
- removed J1: Conn_01x06, Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x06
- removed J10: Conn_01x03, Connector_PinSocket_2.54mm:PinSocket_1x03_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x03
- removed J11: Conn_01x04, Connector_PinSocket_2.54mm:PinSocket_1x04_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x04
- removed J13, J5: Wire pads, Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm, symbol Connector_Generic:Conn_01x01
- removed J14, J15, J6, J7, J8: Conn_01x01, herovco:SolderWire-round_1x01_D0.9mm_OD2.1mm, symbol Connector_Generic:Conn_01x01
- removed J2: Conn_01x03, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x03
- removed J3: Conn_01x04, Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x04
- removed J9: Conn_01x06, Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x06
- added J1: 3_pin_Molex_header, ao_tht:Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical, symbol ao_symbols:3_pin_Molex_header
- added J10, J11, J9: 2_pin_Molex_connector, symbol ao_symbols:2_pin_Molex_connector
- added J19, J20, J21: Wire pad, Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm, symbol Connector_Generic:Conn_01x01
- added J2: 4_pin_Molex_header, Connector_Molex:Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x04
- added J3, J5, J6: 2_pin_Molex_header, ao_tht:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical, symbol ao_symbols:2_pin_Molex_header
- added J7: 3_pin_Molex_connector, ao_tht:Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical, symbol ao_symbols:3_pin_Molex_connector
- added J8: 4_pin_Molex_connector, symbol Connector_Generic:Conn_01x04
- J16: value Conn_01x01 -> Wire pad; footprint herovco:SolderWire-round_1x01_D0.9mm_OD2.1mm -> Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm
Connections:
- net LINK_OUT_CV_B is gone; now on net Main PCB/LINK_IN_CV: J17.7 (Pin_7)
- net LINK_OUT_FM_B is gone; now on net Main PCB/LINK_IN_FM: J17.3 (Pin_3)
- net LINK_OUT_PW_B is gone; now on net Main PCB/LINK_IN_PW: J17.5 (Pin_5)
- net Main PCB/HARD_SYNCA: now also J2.4 (Pin_4)
- net Main PCB/LINK_IN_SYNC: now also J17.1 (Pin_1)
- net Main PCB/LIN_FM_IN: now also J3.2 (Pin_2)
- net Main PCB/SOFT_SYNCA: now also J2.2 (Pin_2)
- net Main PCB/SOFT_SYNC_OFF: now also J2.3 (Pin_3)
- net Main PCB/SYNCA: now also J2.1 (Pin_1)
- net GND: now also J17.2 (Pin_2), J17.4 (Pin_4), J17.6 (Pin_6), J17.8 (Pin_8), J3.1 (Pin_1), J5.1 (Pin_1), J6.1 (Pin_1)
- net GND1: now also J10.1 (Pin_1), J11.1 (Pin_1), J9.1 (Pin_1); no longer J17.2 (Pin_2), J17.4 (Pin_4), J17.6 (Pin_6), J17.8 (Pin_8)
- net Panel mounted components/HARD_SYNCA_P: now also J21.1 (Pin_1), J8.4 (Pin_4); no longer J16.1 (Pin_1)
- net Panel mounted components/SOFT_SYNCA_P: now also J19.1 (Pin_1), J8.2 (Pin_2)
- net Panel mounted components/SOFT_SYNC_OFF_P: now also J20.1 (Pin_1), J8.3 (Pin_3)
- net Panel mounted components/SYNCA_P: now also J16.1 (Pin_1), J8.1 (Pin_1)
- new net +5V_REF: J1.3 (Pin_3)
- new net -5V_REF: J1.1 (Pin_1)
- new net Main PCB/FINE_TUNE: J1.2 (Pin_2)
- new net Outputs and sin/SAW: J6.2 (Pin_2)
- new net Outputs and sin/TRI: J5.2 (Pin_2)
- new net Panel mounted components/+5VREF_P: J7.3 (Pin_3)
- new net Panel mounted components/-5VREF_P: J7.1 (Pin_1)
- new net Panel mounted components/FINE_TUNE_P: J7.2 (Pin_2)
- new net Panel mounted components/LIN_FM_IN_J: J9.2 (Pin_2)
- new net Panel mounted components/SAW_P: J11.2 (Pin_2)
- new net Panel mounted components/TRI_P: J10.2 (Pin_2)
Other:
- sheet Front PCB renamed Main PCB
- sheet Octave and sync switches renamed Panel mounted components
- sheet Jacks, power, etc ports: added none; removed LIN_FM_IN_J, PWMIN_J, SIN, V_OCT_J
- sheet Main PCB: file sidekickvco_front.kicad_sch -> sidekickvco_main.kicad_sch
- sheet Main PCB ports: added FINE_TUNE; removed PULSE_OUT, PWMIN, SAW_OUT, TRIANGLE_OUT, V_OCT
- sheet Outputs and sin: file sidekickvco_back.kicad_sch -> sidekickvco_outputs.kicad_sch
- sheet Outputs and sin ports: added SAW, TRI; removed PULSE_OUT_S, SAW_OUT_S, SIN, TRIANGLE_OUT_S
- sheet Panel mounted components: file octave.kicad_sch -> panel.kicad_sch
- sheet Panel mounted components ports: added +5VREF_P, -5VREF_P, FINE_TUNE_P, LIN_FM_IN_J, SAW_P, TRI_P; removed none
- note added: "MAIN PCB"
- note removed: "BACK PCB"
- note removed: "FRONT PCB"
- moved on the sheet: J12, J17, J4

Commit message: Daughterboard mounting
Parts:
- J19, J20, J21: footprint Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm -> sidekickvco:SolderWire-round_1x01_D0.9mm_OD2.1mm
Connections:
- net Main PCB/HARD_SYNCA: now also J2.1 (Pin_1); no longer J2.4 (Pin_4)
- net Main PCB/SOFT_SYNCA: now also J2.4 (Pin_4); no longer J2.2 (Pin_2)
- net Main PCB/SYNCA: now also J2.2 (Pin_2); no longer J2.1 (Pin_1)
- net Panel mounted components/HARD_SYNCA_P: now also J16.1 (Pin_1), J8.1 (Pin_1); no longer J21.1 (Pin_1), J8.4 (Pin_4)
- net Panel mounted components/SOFT_SYNCA_P: now also J21.1 (Pin_1), J8.4 (Pin_4); no longer J19.1 (Pin_1), J8.2 (Pin_2)
- net Panel mounted components/SYNCA_P: now also J19.1 (Pin_1), J8.2 (Pin_2); no longer J16.1 (Pin_1), J8.1 (Pin_1)
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm" (id 2) (at 160.02 99.06 0)
+    (property "Footprint" "sidekickvco:SolderWire-round_1x01_D0.9mm_OD2.1mm" (id 2) (at 160.02 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm" (id 2) (at 160.02 101.6 0)
+    (property "Footprint" "sidekickvco:SolderWire-round_1x01_D0.9mm_OD2.1mm" (id 2) (at 160.02 101.6 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm" (id 2) (at 160.02 104.14 0)
+    (property "Footprint" "sidekickvco:SolderWire-round_1x01_D0.9mm_OD2.1mm" (id 2) (at 160.02 104.14 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (pin "SOFT_SYNCA" input (at 95.25 99.06 0)
+    (pin "SOFT_SYNCA" input (at 95.25 104.14 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (pin "SYNCA" output (at 95.25 96.52 0)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (pin "HARD_SYNCA" input (at 95.25 104.14 0)
+    (pin "SYNCA" output (at 95.25 99.06 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (pin "HARD_SYNCA" input (at 95.25 96.52 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (pin "SYNCA_P" input (at 166.37 96.52 180)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (pin "SOFT_SYNCA_P" output (at 166.37 99.06 180)
+    (pin "SYNCA_P" input (at 166.37 99.06 180)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (pin "SOFT_SYNCA_P" output (at 166.37 104.14 180)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (pin "HARD_SYNCA_P" output (at 166.37 104.14 180)
+    (pin "HARD_SYNCA_P" output (at 166.37 96.52 180)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (reference "D4") (unit 1) (value "1N5817") (footprint "ao_tht:D_DO-41_SOD81_P10.16mm_Horizontal")
     )
+    (path "/00000000-0000-0000-0000-0000619704e4/083e1a17-4d2b-41f4-9f1b-ca7db66d10c6"
+      (reference "GRAF1") (unit 1) (value "board") (footprint "sidekickvco:sidekick_daughterboard")
+    )
     (path "/00000000-0000-0000-0000-000061a0b1ab/00000000-0000-0000-0000-000061680e82"
       (reference "GRAF2") (unit 1) (value "Holes") (footprint "herovco_panel:herovco_panel_holes")
@@
       (reference "GRAF4") (unit 1) (value "CC0 logo") (footprint "ao_tht:CC0_logo")
     )
+    (path "/00000000-0000-0000-0000-0000619704e4/9d959ba1-c0bd-4c41-a733-888a168ca5b2"
+      (reference "H1") (unit 1) (value "MountingHole") (footprint "ao_tht:MountingHole_3.2mm_M3")
+    )
+    (path "/00000000-0000-0000-0000-0000619704e4/6a9f627f-79c9-4a99-88fc-ef4d97fd2494"
+      (reference "H2") (unit 1) (value "MountingHole") (footprint "ao_tht:MountingHole_3.2mm_M3")
+    )
     (path "/338b4002-dc3b-4d3b-9469-06af0468e64e"
       (reference "J1") (unit 1) (value "3_pin_Molex_header") (footprint "ao_tht:Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical")
@@
     )
     (path "/911ffe4f-3d00-41e7-aee1-294c1032435d"
-      (reference "J19") (unit 1) (value "Wire pad") (footprint "Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm")
+      (reference "J19") (unit 1) (value "Wire pad") (footprint "sidekickvco:SolderWire-round_1x01_D0.9mm_OD2.1mm")
     )
     (path "/b90ac68d-fd97-4686-85c7-a191a2ceab55"
-      (reference "J20") (unit 1) (value "Wire pad") (footprint "Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm")
+      (reference "J20") (unit 1) (value "Wire pad") (footprint "sidekickvco:SolderWire-round_1x01_D0.9mm_OD2.1mm")
     )
     (path "/cf654bc3-e334-40ed-8c03-17469c121efa"
-      (reference "J21") (unit 1) (value "Wire pad") (footprint "Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm")
+      (reference "J21") (unit 1) (value "Wire pad") (footprint "sidekickvco:SolderWire-round_1x01_D0.9mm_OD2.1mm")
     )
     (path "/00000000-0000-0000-0000-000061a0b1ab/00000000-0000-0000-0000-00005f51c6f1"

Commit message: Revised layout
Connections:
- net Main PCB/+2V_REF: now also J4.3 (Pin_3); no longer J4.1 (Pin_1)
- net Main PCB/-2V_REF: now also J4.1 (Pin_1); no longer J4.3 (Pin_3)
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (pin "-2V_REF" output (at 95.25 87.63 0)
+    (pin "-2V_REF" output (at 95.25 82.55 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (pin "+2V_REF" output (at 95.25 82.55 0)
+    (pin "+2V_REF" output (at 95.25 87.63 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )

Commit message: Pre prototype revisions, README revision
Parts:
- renumbered J17 to J1, J8 to J10, J9 to J11, J10 to J12, J11 to J13, J16 to J14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
